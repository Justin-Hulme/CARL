# Keil uVision project car_motors.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: car_motors
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: C:\Users\18dpa\AppData\Local\Arm\Packs\ARM\CMSIS\6.2.0\CMSIS\Core\Include;..\..\..\..\..\..\..\..\..\AppData\Local\Arm\Packs\Keil\NUCLEO-L476RG_BSP\1.1.0\Examples\Blinky\STM32CubeMX\NUCLEO-L476RG\STM32CubeMX\Drivers\CMSIS\Device\ST\STM32L4xx\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6314W
  group Source Group 1
    ./: main.c
    ../Car/: startup_stm32l476xx.s
